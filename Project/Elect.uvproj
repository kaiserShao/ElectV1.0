# Keil uVision project Elect.uvproj, settings and files
target Elect (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Elect
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\RTOS;..\User;..\BIOS;..\CMSIS;..\Device
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c
  group RTOS
    ../RTOS/: RTX_CM3.lib RTX_Conf_CM.c
  group BIOS
    ../BIOS/: aBIOS.c
  group Device
    ../Device/: Nokia5110.c
  group App
    ../User/: main.c
